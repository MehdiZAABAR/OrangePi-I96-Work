DEPENDS_i96 = "i96"
